# Enable native build for libconfig so it can be used by processor-native
BBCLASSEXTEND = "native"
